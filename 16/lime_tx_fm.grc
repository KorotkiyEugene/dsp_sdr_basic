options:
  parameters:
    generate_options: qt_gui
    id: lime_tx_fm
    output_language: python
    title: Lime Tx FM
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: interp
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rf_freq
  id: variable
  parameters:
    value: 65e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_samp_rate*interp
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: int(audio_samp_rate)
    fh: '-1.0'
    max_dev: 25e3
    quad_rate: int(samp_rate)
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gnuradio/host/lime/guitar.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch1: '1'
    rf_freq: rf_freq
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_nbfm_tx_0, '0', limesdr_sink_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0_0_0_0_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']

metadata:
  file_format: 1
