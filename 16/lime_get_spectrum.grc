options:
  parameters:
    generate_options: qt_gui
    id: lime_get_spectrum
    output_language: python
    title: Lime Get Spectrum
  states: {}

blocks:
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50'
    step: '1'
    stop: '450'
    value: '100'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: samp_rate
    ch_align: 'False'
    channel_mode: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: rf_freq*1e6
    samp_rate: samp_rate
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_sink_x_0, '0']
- [limesdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
