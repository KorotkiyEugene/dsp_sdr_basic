options:
  parameters:
    generate_options: qt_gui
    id: fm_demod_from_file
    output_language: python
  states: {}

blocks:
- name: decimation1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation2
    quad_rate: samp_rate/decimation1
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/decimation1/decimation2)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: recorded_signal.dat
    repeat: 'False'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/decimation1
    decim: decimation1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation1/decimation2
    fc: '0'
    fftsize: 1024*8
    type: float
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation1
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', low_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-28-gf87ee512
