options:
  parameters:
    generate_options: qt_gui
    id: rtl_receive
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_samp_rate)
  states: {}
- name: blocks_throttle_0_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/gnuradio/host/am_demod/audio_out.wav
    samp_rate: int(audio_samp_rate)
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gnuradio/host/am_demod/audio.wav
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '8192'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: audio_samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle_0_0, '0', audio_sink_0, '0']
- [blocks_throttle_0_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_throttle_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0_0, '0']

metadata:
  file_format: 1
