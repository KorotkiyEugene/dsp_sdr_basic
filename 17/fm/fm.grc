options:
  parameters:
    generate_options: qt_gui
    id: fm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Fc
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: interp
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_samp_rate*interp
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-Fc'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: interp
    quad_rate: samp_rate
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: audio_samp_rate
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/parallels/Desktop/gnuradio_custom/fm/demod_audio
    samp_rate: int(audio_samp_rate)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/parallels/Desktop/gnuradio_custom/fm/guitar.wav
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fc = 100e3, fm_dev=25e3, fs = 200e3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Custom FM Modulator',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.fm_dev = fm_dev
              self.fc = fc
              self.fs = fs
              self.phase = 0

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              
              sig_len = len(input_items[0])
              
              df = input_items[0] * self.fm_dev
              f = df + self.fc
              
              for i in range(0, sig_len):
                  self.phase = self.phase + 2*np.pi*f[i]/self.fs
                  output_items[0][i] = np.cos(self.phase)
              
              return len(output_items[0])
    fc: Fc
    fm_dev: 25e3
    fs: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    Fs: samp_rate
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import math
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, fm_dev=25e3, Fs = 200e3):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Custom FM Demodulator',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.float32]
              )
              self.fm_dev = fm_dev
              self.Fs = Fs
              self.last_angle = 0

          def work(self, input_items, output_items):    
              for i in range(0, len(input_items[0])):
                  angle = np.angle(input_items[0][i])
                  angle_change = angle - self.last_angle
                  if angle_change > math.pi:
                      angle_change -= 2 * math.pi
                  elif angle_change < -math.pi:
                      angle_change += 2 * math.pi
                  self.last_angle = angle
                  output_items[0][i] = angle_change * self.Fs / (2 * math.pi * self.fm_dev)
              
              return len(output_items[0])
    fm_dev: 25e3
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '300'
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: ''
    interp: interp
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: interp
    fbw: ''
    interp: '1'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', analog_wfm_rcv_0, '0']
- [blocks_multiply_xx_0, '0', epy_block_0_0, '0']
- [blocks_throttle_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle_0, '0']
- [epy_block_0, '0', hilbert_fc_0, '0']
- [epy_block_0, '0', qtgui_sink_x_0, '0']
- [epy_block_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [hilbert_fc_0, '0', blocks_multiply_xx_0, '0']
- [hilbert_fc_0, '0', qtgui_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', epy_block_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_wavfile_sink_0, '0']
- [rational_resampler_xxx_0_0_0, '0', qtgui_sink_x_0_0_0, '0']

metadata:
  file_format: 1
