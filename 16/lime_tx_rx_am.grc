options:
  parameters:
    generate_options: qt_gui
    id: lime_rx_tx_am
    output_language: python
    title: Lime Tx Rx AM
  states: {}

blocks:
- name: Fc
  id: variable_qtgui_range
  parameters:
    label: Fc
    orient: Qt.Horizontal
    start: '-samp_rate/2'
    step: '1'
    stop: samp_rate/2
    value: 100e3
  states: {}
- name: audio_samp_rate
  id: variable
  parameters:
    value: 44.1e3
  states: {}
- name: decim
  id: variable
  parameters:
    value: interp
  states: {}
- name: interp
  id: variable
  parameters:
    value: '20'
  states: {}
- name: rf_freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50'
    step: '0.1'
    stop: '1500'
    value: '200'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_samp_rate*interp
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '55'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: 10e3
    offset: '0'
    phase: '0'
    samp_rate: audio_samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-Fc'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Fc
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: int(audio_samp_rate)
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/gnuradio/host/am_demod/audio_out.wav
    samp_rate: int(audio_samp_rate)
  states: {state: disabled}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    file: /home/parallels/dsp_sdr_basic/14/python/audio.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch0: '1'
    pa_path_ch1: '1'
    rf_freq: rf_freq*1e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    ch_align: 'True'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: rf_freq*1e6
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 20e3
    decim: decim
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    fbw: ''
    interp: interp
    taps: ''
    type: fff
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0_1, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_2, '0', blocks_multiply_xx_1, '1']
- [blocks_complex_to_mag_0, '0', audio_sink_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [blocks_multiply_xx_1, '0', limesdr_sink_0_0, '0']
- [blocks_multiply_xx_1, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [blocks_wavfile_source_0_0, '0', rational_resampler_xxx_0_0, '0']
- [limesdr_source_0, '0', blocks_multiply_xx_0_0, '0']
- [limesdr_source_0, '0', qtgui_freq_sink_x_0_0_0_0_1, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0_0_0_0_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
