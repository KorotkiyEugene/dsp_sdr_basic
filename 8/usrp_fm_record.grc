options:
  parameters:
    generate_options: qt_gui
    id: usrp_fm_record
    output_language: python
    title: USRP FM Record
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '80'
    step: '0.1'
    stop: '110'
    value: '100'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: recorded_signal.dat
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq*1e6
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-28-gf87ee512
