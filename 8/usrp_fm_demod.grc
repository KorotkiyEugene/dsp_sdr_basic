options:
  parameters:
    generate_options: qt_gui
    id: usrp_fm_demod
    output_language: python
    title: USRP Receive FM
  states: {}

blocks:
- name: decimation1
  id: variable
  parameters:
    value: '10'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: '80'
    step: '0.1'
    stop: '110'
    value: '100'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '60'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation2
    quad_rate: samp_rate/decimation1
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/decimation1/decimation2)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate/decimation1
    decim: decimation1
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation1/decimation2
    fc: '0'
    fftsize: 1024*8
    type: float
  states: {}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation1
    fc: '0'
    fftsize: 1024*8
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq*1e6
    gain0: rx_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_1, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.6.0-28-gf87ee512
