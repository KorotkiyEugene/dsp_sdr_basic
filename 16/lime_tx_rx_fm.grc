options:
  parameters:
    generate_options: qt_gui
    id: lime_tx_rx_fm
    output_language: python
    title: Lime Tx Rx FM
  states: {}

blocks:
- name: audio_samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: decimation1
  id: variable
  parameters:
    value: '2'
  states: {}
- name: decimation2
  id: variable
  parameters:
    value: '5'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '50'
    step: '0.1'
    stop: '1500'
    value: '250'
  states: {}
- name: interp
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_samp_rate*interp
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: TX Gain
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: '60'
    value: '60'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: decimation2
    quad_rate: samp_rate/decimation1
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(audio_samp_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(samp_rate)
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate*3/20/6
  states: {state: disabled}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: int(samp_rate/decimation1/decimation2)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/parallels/dsp_sdr_basic/16/guitar.wav
    repeat: 'True'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: tx_gain
    oversample: '0'
    pa_path_ch0: '1'
    pa_path_ch1: '1'
    rf_freq: freq*1e6
    samp_rate: samp_rate
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: '0'
    calibr_bandw_ch0: '0'
    ch_align: 'False'
    channel_mode: '0'
    digital_bandw_ch0: '0'
    gain_dB_ch0: rx_gain
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: freq*1e6
    samp_rate: samp_rate
  states: {}
- name: qtgui_freq_sink_x_0_0_0_0_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    name: '"Rx spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation1/decimation2
    fc: '0'
    fftsize: 1024*8
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_1
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/decimation1
    fc: '0'
    fftsize: 1024*8
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: decimation1
    fbw: ''
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_1, '0']
- [analog_wfm_rcv_0, '0', qtgui_sink_x_0_0, '0']
- [analog_wfm_tx_0, '0', limesdr_sink_0, '0']
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0_0_0_0_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [limesdr_source_0, '0', qtgui_sink_x_0, '0']
- [limesdr_source_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0_1, '0']

metadata:
  file_format: 1
